Commit message: add obj size randomizer

File: gym_gazebo/envs/assets/urdf/objs/sphere.urdf (robot description, URDF)
Before this commit: robot red_point, 1 links, 0 joints
Links:
- link link_red_point: mass 5.0 -> 1.0; geometry collision sphere radius=0.033; visual sphere radius=0.033
